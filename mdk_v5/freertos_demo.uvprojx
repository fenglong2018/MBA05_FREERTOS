# Keil uVision project freertos_demo.uvprojx, settings and files
target at_start_f435_ac5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f435_freertos +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F435VGT7,AT_START_F435_V1
  c include: ..\f435\inc;..\libraries\drivers\inc;..\libraries\cmsis\cm4\device_support;..\libraries\cmsis\cm4\core_support;..\freertos\source\include;..\freertos\source\portable\memmang;..\freertos\source\portable\rvds\ARM_CM4F;..\user;..\user\app\inc;..\user\bsp\inc;..\user\hal\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group app
    ../user/app/src/: main.c vKeyTask.c vBuzTask.c
  group hal
    ../user/hal/src/: test.c Hal_Buzzer.c Hal_Key.c Hal_Led.c
  group board
    ../f435/src/: at32f435_437_clock.c at32f435_437_int.c include_port.c at32f435_board_usart.c at32f435_437_board.c
  group firmware
    ../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group startup
    ../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group freertos
    ../freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/source/portable/memmang/: heap_4.c
